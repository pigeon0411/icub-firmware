# Keil uVision project rfe-stm32app.uvprojx, settings and files
target rfe-stm32app (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32app
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32HAL STM32HAL_BOARD_RFE
  c misc: --cpp11
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\src\imported\Inc;..\src\imported\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\src\imported\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\libs\lowlevel\stm32hal\src\driver\stm32l4-v183\inc;..\..\..\..\..\libs\lowlevel\stm32hal\src\driver\stm32l4-v183\inc\Legacy;..\..\..\..\..\libs\lowlevel\stm32hal\src\board\rfe\inc;..\..\..\..\..\libs\lowlevel\stm32hal\cubemx\rfe\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\libs\lowlevel\stm32hal\cubemx\rfe\Drivers\CMSIS\Include;..\..\..\..\..\embot\common;..\..\..\..\..\embot\binary;..\..\..\..\..\embot\
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\rfe-application0offset.sct
  link misc: --diag_suppress=L6329
  group rfe-app
    ../src/: main-application.cpp
    ../src/imported/Src/: usbd_cdc_if.c embot_hw_usb.cpp
  group stm32hal
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.rfe.lib
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/startup/: stm32hal.startup.rfe.s
  group stm32hal-config
    ../cfg/: stm32hal_stg.h
  group stm32hal-src
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32l4-v183/src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_timebase_tim_template.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c system_stm32l4xx.c
  group appl
    ../src/imported/Src/: adc.c BNO055.c can.c can_utility.c dma.c gpio.c i2c.c MPU9250.c RFE_Expression.c rng.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c tim.c tlc59711.c usb_device.c usb_parser.c usbd_conf.c usbd_desc.c
  group stm-usb
    ../src/imported/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../src/imported/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group sys
    ../src/imported/sys/: startup_stm32l452xx.s system_stm32l4xx.c
    ../../../../../embot/sys/: slim_retarget_io.c
software components: CMSIS:CORE 5.1.1
